## zmk/two_enc/zmk-config/boards/shields/thermal_pad/Kconfig.defconfing
```kconfig
if SHIELD_THERMAL_PAD

config ZMK_KEYBOARD_NAME
    default "thermal pad"

endif
```
